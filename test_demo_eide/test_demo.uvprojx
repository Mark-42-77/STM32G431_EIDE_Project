# Keil uVision project test_demo.uvprojx, settings and files
target test_demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: test_demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: .;..\test_demo\Core\Inc;..\test_demo\Drivers\STM32G4xx_HAL_Driver\Inc;..\test_demo\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\test_demo\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\test_demo\APP;..\test_demo\Drivers\CMSIS\Include;.cmsis\include;..\test_demo\MDK-ARM\RTE\_test_demo
  asm define: USE_HAL_DRIVER,STM32G431xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../test_demo/APP/: mydefine.h system.c scheduler.c led_app.c key_app.c lcd.c lcd_app.c uart_app.c
  group Drivers/CMSIS
    ../test_demo/Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../test_demo/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Application/User/Core
    ../test_demo/Core/Src/: main.c gpio.c stm32g4xx_it.c stm32g4xx_hal_msp.c dma.c usart.c
  group Application/MDK-ARM
    ../test_demo/MDK-ARM/: startup_stm32g431xx.s
